Commit message: 统一项目标准，准备重跑结果吧

File: gym_pybullet_drones/assets/cylinderg.urdf (robot description, URDF)
Before this commit: robot cylinder.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry visual cylinder length=0.1 radius=0.08
